# Keil uVision project PID_AircraftBalancingPole_DirectRunCalibrated.uvprojx, settings and files
target ProjectDirectRunCalibrated (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PID_AircraftBalancingPole_DirectRunCalibrated +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,PROJECT_DIRECT_RUN_BUILD,PROJECT_DIRECT_RUN_CALIBRATED_BUILD
  c include: ../BuildProfiles/DirectRunCalibrated/Core/Inc;../BuildProfiles/DirectRunCalibrated/MyCode;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/MyCode
    ../BuildProfiles/DirectRunCalibrated/MyCode/: software_i2c.c mpu6050.c pid_controller.c balance_controller.c
  group Application/User/Core
    ../BuildProfiles/DirectRunCalibrated/Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../BuildProfiles/DirectRunCalibrated/Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
